# IAR project MF-D1_Mifare_GPIO.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; USER_INPUT_ENABLE; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED; __SL__
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../common/; ../../driverlib/; ../../inc/; C:\TI\CC3200SDK_1.3.0\cc3200-sdk\oslib; C:\TI\CC3200SDK_1.3.0\cc3200-sdk\third_party\FreeRTOS\source; C:\TI\CC3200SDK_1.3.0\cc3200-sdk\third_party\FreeRTOS\source\include; C:\TI\CC3200SDK_1.3.0\cc3200-sdk\third_party\FreeRTOS\source\portable\IAR\ARM_CM4; ../../simplelink/; ../../simplelink/source; ../../simplelink/include; ../../simplelink_extlib/provisioninglib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MF-D1_Mifare_GPIO1107.bin
  ILINK.IlinkOutputFile: MF-D1_Mifare_GPIO.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ../../driverlib/ewarm/Release/Exe/driverlib.a; D:\CC3200SDK_1.3.0\cc3200-sdk\example\MF-D1_MIfare_GPIO_Battery\MF-D1_MifareLib0320.a; ../../simplelink/ewarm/NON_OS/Exe/simplelink.a; ../../netapps/http/client/ewarm/HTTPClientMinLib/Exe/webclient.a; ../../netapps/json/ewarm/Release/Exe/json.a; C:\TI\CC3200SDK_1.3.0\cc3200-sdk\oslib\ewarm\free_rtos\Exe\free_rtos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; __SL__
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../common/; ../../driverlib/; ../../inc/; ../../simplelink/; ../../simplelink/source; ../../simplelink/include; ../../simplelink_extlib/provisioninglib
  OBJCOPY.OOCOutputFile: MF-D1_Mifare_GPIO1102.bin
  ILINK.IlinkAdditionalLibs: ../../driverlib/ewarm/Release/Exe/driverlib.a; MF-D1_MifareLib.a; ../../simplelink/ewarm/NON_OS/Exe/simplelink.a; ../../netapps/http/client/ewarm/HTTPClientMinLib/Exe/webclient.a; ../../netapps/json/ewarm/Release/Exe/json.a
  group (top)
    ./: gpio_if.c main.c pinmux.c types.h
    ../common/: i2c_if.c startup_ewarm.c timer_if.c timer_if.h uart_if.c udma_if.c utils_if.c
    ../../simplelink/source/: nonos.c
